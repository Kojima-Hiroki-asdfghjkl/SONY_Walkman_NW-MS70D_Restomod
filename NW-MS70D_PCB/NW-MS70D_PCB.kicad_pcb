# Repository Kojima-Hiroki-asdfghjkl/SONY_Walkman_NW-MS70D_Restomod

File README.md:

# SONY_Walkman_NW-MS70D_Restomod
SONY Walkman NW-MS70D をレストモッドします．

## KiCad design NW-MS70D_PCB/NW-MS70D_PCB.kicad_pcb

Parts:
C1, C2, C3, C4, C6, C8, C15, C16: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C12, C13, C14: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7: 1.0u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11, C17: 0.047u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C18, C19: C; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C20: 0.01u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: WS2812B-2020; LED_WS2812B-2020_PLCC4_2.0x2.0mm
J1: Micro_SD_Card_Det2; microSD_HC_Hirose_DM3BT-DSF-PEJS
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R1, R2, R8, R9, R11, R12, R13, R14, R15, R16: 47K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4: 5.1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 20K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 33K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 3.01K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: ESP32-MINI-1
U2: PIC18F27Q43-I/STX; VQFN28_STX_MCH
U3: STM32F723VETx; LQFP-100_14x14mm_P0.5mm
U4: SN74CB3Q3257RGYR; RGY16_2P55X2P05
U5: PCM5102A; TSSOP-20_4.4x6.5mm_P0.65mm
U6: ESP-PSRAM64H; SOIC-8_3.9x4.9mm_P1.27mm
U7: 25CSM04xxSN; SOIC-8_3.9x4.9mm_P1.27mm
U8: PIC18F47Q43T-I/MP; QFN40_MP_MCH
U9: USBLC6-2SC6; SOT-23-6
Y1: SG-210STF 16.000000MHz L; Oscillator_SMD_ECS_2520MV-xxx-xx-4Pin_2.5x2.0mm
Y2: Crystal_32.768kHz; Crystal_SMD_EuroQuartz_EQ161-2Pin_3.2x1.5mm

Connections:
+3.3V: C1.1, C2.1, C3.1, C8.1, C15.1, C16.1, C20.1, D1.4 (VDD), J1.4 (VDD), R1.1, R8.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, U2.17 (VDD), U3.6 (VBAT), U3.11 (VDD), U3.20 (VREF+), U3.21 (VDDA), U3.27 (VDD), U3.50 (VDD), U3.54 (VDDPHYHS), U3.75 (VDD), U3.100 (VDD), U4.16 (VCC), U6.8 (VCC), U7.3 (~WP), U7.7 (~HOLD), U7.8 (V_{CC}), U8.26 (VDD), Y1.4 (VDD)
+3.3VA: C4.1, R2.1, U5.1 (CPVDD), U5.8 (AVDD), U5.20 (DVDD)
+5V: J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), R5.1, U9.5 (VBUS)
DAC_MUTE: R2.2, U5.17 (XSMT)
ESP_RST: U2.2 (RA3), U8.20 (RA3)
ESP_RX: U2.18 (RB0), U8.3 (RD5)
ESP_TX: U2.19 (RB1), U8.4 (RD6)
GNDA: C4.2, C5.2, C6.2, U5.3 (CPGND), U5.9 (AGND), U5.10 (DEMP), U5.11 (FLT), U5.16 (FMT), U5.19 (DGND)
GNDD: C1.2, C2.2, C3.2, C8.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, D1.2 (VSS), J1.6 (VSS), J1.9 (DET_B), J1.SH (SHIELD), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.SH (SHIELD), R3.2, R4.2, R6.2, R7.2, R9.2, U2.5 (VSS), U2.16 (VSS), U2.29 (VSS), U3.10 (VSS), U3.19 (VSSA), U3.26 (VSS), U3.49 (VSS), U3.74 (VSS), U3.99 (VSS), U4.8 (GND), U4.15 (*OE), U4.17 (EPAD), U6.4 (VSS), U7.4 (V_{SS}), U8.6 (VSS), U8.27 (VSS), U8.41 (VSS), U9.2 (GND), Y1.2 (GND)
I2S_BCLK: U4.7 (2A), U5.13 (BCK)
I2S_BCLK1: U3.29 (PA5), U4.5 (2B1)
I2S_LRCLK: U4.4 (1A), U5.15 (LRCK)
I2S_LRCLK1: U3.28 (PA4), U4.2 (1B1)
I2S_MCLK: U4.12 (4A), U5.12 (SCK)
I2S_MCLK1: U3.32 (PC4), U4.14 (4B1)
I2S_SDATA: U4.9 (3A), U5.14 (DIN)
I2S_SDATA1: U3.31 (PA7), U4.11 (3B1)
ICSP_CLK: U2.24 (RB6/ICSPCLK), U8.14 (ICSPCLK/RB6)
ICSP_DAT: U2.25 (RB7/ICSPDAT), U8.15 (ICSPDAT/RB7)
MULTIPLEXER_SELECT: U2.28 (RA1), U4.1 (S), U8.18 (RA1)
NEOPIXEL: D1.3 (DIN), U2.27 (RA0), U8.17 (RA0)
unnamed: J2.A5 (CC1), R4.1
unnamed: J2.B5 (CC2), R3.1
unnamed: U1.1 (GND), U1.2 (GND), U1.27 (GND), U1.38 (GND), U1.39 (GND), U1.40 (GND), U1.41 (GND), U1.42 (GND), U1.43 (GND), U1.44 (GND), U1.45 (GND), U1.46 (GND), U1.47 (GND), U1.48 (GND), U1.49 (GND), U1.50 (GND), U1.51 (GND), U1.52 (GND), U1.53 (GND), U1.54 (GND), U1.55 (GND)
unnamed: C14.1, U3.48 (VCAP_1)
unnamed: C13.1, U3.73 (VCAP_2)
unnamed: C7.2, U5.4 (CAPM)
unnamed: C7.1, U5.2 (CAPP)
unnamed: C6.1, U5.18 (LDOO)
unnamed: C5.1, U5.5 (VNEG)
OUT_L: U5.6 (OUTL)
OUT_R: U5.7 (OUTR)
PIC_I2C_SCL: U2.12 (RC4), U8.10 (RB2)
PIC_I2C_SDA: U2.11 (RC3), U8.9 (RB1)
PIC_RST: C17.1, R11.2, U2.26 (RE3/*MCLR/VPP), U8.16 (VPP/*MCLR/RE3)
PIC_RX2: U2.13 (RC5), U8.32 (RC2)
PIC_TX2: U2.14 (RC6), U8.33 (RC3)
PSRAM_CE: U3.92 (PB6), U6.1 (~CE)
PSRAM_CLK: U3.36 (PB2), U6.6 (SCLK)
PSRAM_IO0: U3.58 (PD11), U6.2 (SO/SIO)
PSRAM_IO1: U3.59 (PD12), U6.5 (SI/SIO)
PSRAM_IO2: U3.1 (PE2), U6.3 (SIO2)
PSRAM_IO3: U3.23 (PA1), U6.7 (SIO3)
ROM_CLK: U2.22 (RB4), U7.6 (SCK), U8.1 (RC7)
ROM_CS: U2.23 (RB5), U7.1 (~CS), U8.2 (RD4)
ROM_MISO: U2.20 (RB2), U7.2 (SO), U8.39 (RC5)
ROM_MOSI: U2.21 (RB3), U7.5 (SI), U8.40 (RC6)
RTC_XTAL_IN: C19.1, U2.9 (RC1), U8.31 (RC1), Y2.2
RTC_XTAL_OUT: C18.1, U2.8 (RC0), U8.30 (RC0), Y2.1
SD_CLK: J1.5 (CLK), U3.80 (PC12)
SD_CMD: J1.3 (CMD), R16.2, U3.83 (PD2)
SD_DAT0: J1.7 (DAT0), R12.2, U3.66 (PC9)
SD_DAT1: J1.8 (DAT1), R13.2, U3.65 (PC8)
SD_DAT2: J1.1 (DAT2), R14.2, U3.78 (PC10)
SD_DAT3: J1.2 (DAT3/CD), R15.2, U3.79 (PC11)
SD_DETA: J1.10 (DET_A), R1.2
STM_BOOT: R9.1, U3.94 (BOOT0)
STM_REXTPHYHS: R7.1, U3.53 (REXTPHYHS)
STM_RST: C11.1, R8.2, U2.1 (RA2), U3.14 (NRST), U8.19 (RA2), Y1.1 (Tri-State)
STM_V12PHYHS: C12.1, U3.55 (V12PHYHS)
STM_XTAL_IN: U3.12 (PH0), Y1.3 (OUT)
USB_D+: U3.57 (PB15), U9.4 (I/O2)
USB_D-: U3.56 (PB14), U9.6 (I/O1)
USB_DETECT: R5.2, R6.1, U3.52 (PB13)
usb_d+: J2.A6 (D+), J2.B6 (D+), U9.3 (I/O2)
usb_d-: J2.A7 (D-), J2.B7 (D-), U9.1 (I/O1)

Notes on the sheet:
STM32F723
遅延リセットはパターンのみ実装しておく

Board: 4 copper layers, 46 parts (7 on the bottom side), 55 nets.
